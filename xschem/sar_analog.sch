v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {ipin.sym} -200 -120 0 0 {name=p1 lab=dac_b[9:0]}
C {ipin.sym} -200 -80 0 0 {name=p2 lab=sample}
C {ipin.sym} -200 -40 0 0 {name=p3 lab=cmp_clk}
C {ipin.sym} -200 0 0 0 {name=p4 lab=vin}
C {ipin.sym} -200 40 0 0 {name=p5 lab=vref}
C {opin.sym} 200 -120 0 0 {name=p6 lab=cmp_out}
C {opin.sym} 200 -80 0 0 {name=p7 lab=cmp_out_n}
C {iopin.sym} 0 -40 0 0 {name=p8 lab=vdd}
C {iopin.sym} 0 0 0 0 {name=p9 lab=vss}
